# Keil uVision project WeighMachine.uvprojx, settings and files
target WeighMachine (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SC32F12TS8 SinOneMicroelectronics
  pack: SinOne.SinOneM_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: WeighMachine +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: SC32f12xx
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\User;..\Drivers;..\Apps;..\CMSIS
  memory RVCT4: ROM 0x08000000 size 0x00040000
  memory RVCT9: ROM 0x20000000 size 0x00004000
  group User
    ../User/: main.c system_sc32f1xxx.c SC_it.c SC_Init.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_option.c sc32f1xxx_rcc.c sc32f1xxx_gpio.c
  group Startup
    ./: startup_sc32f12xx.s
